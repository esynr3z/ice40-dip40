# Repository esynr3z/ice40-dip40

File README.md:

# iCE40 breakout board

Miniature FPGA development board with DIP40 gabarits

## Features

* Lattice iCE40UP5KSG48 (iCE40 Ultra, iCE40 UltraPlus compatible - see Notes)
* Size 17.78mm x 50.8mm (DIP40)
* 16 MHz external generator
* Input power voltage: 5V (USB Micro B)
* USB data lines routed to FPGA
* 8Mb SPI flash for programming
* 34 IO pins available (3.3V)
* CRESET push button and CDONE led
* User led and user push button
* RGB led connected to internal driver

## Board

**BOARD IS NOT TESTED YET**

## Notes

Board is routed for iCE40UP5KSG48 (iCE40 UltraPlus family), but list of supported FPGAs is quite wider:

* iCE40 Ultra - iCE5LP1KSG48, iCE5LP2KSG48, iCE5LP4KSG48
* iCE40 UltraPlus - iCE40UP3KSG48, iCE40UP5KSG48

There is only one difference in pinout between these families you should pay attention for:

| Func | iCE40 Ultra | iCE40 UltraPlus |
|-----:|------------:|----------------:|
| RGB2 |          39 |              41 |
| RGB1 |          40 |              40 |
| RGB0 |          41 |              39 |

## KiCad design board/ice40-dip40.kicad_pcb

Parts:
C1, C9: 1u; C_0603
C2, C4, C10, C11, C12, C13, C15, C17, C18, C19: 100n; C_0603
C3, C7, C8: 2.2u; C_0603
C20: 10u; C_0603
D1: CDBU0520; SOD-523F
D2: CLMVC-FKC-CGJJM569aBB7a343; LED_Cree-PLCC4_2x2mm_CW
D3: LED_GREEN; LED_0603
D4: LED_RED; LED_0603
D5: LED_ORANGE; LED_0603
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J2, J3: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J4: USB_B_Micro; USB_Micro-B_Wurth_629105136821
R1, R2, R4, R5, R6, R12: 10k; R_0603
R3: 1.5k; R_0603
R7: 82; R_0603
R8, R9: 22; R_0603
R10, R13: 1k; R_0603
R11: 2.2k; R_0603
R14, R15: 68; R_0603
SW1, SW2: SW_Push; PTS830
U1: W25Q80DVSNIG; SOIC-8_3.9x4.9mm_P1.27mm
U2: MIC5355-S4YMME; MSOP-8-1EP_3x3mm_P0.65mm_EP2.54x2.8mm_ThermalVias
U3: ICE40UP5K-SG48I; QFN-48-1EP_7x7mm_P0.5mm_EP5x5mm_ThermalVias
X1: ECS-2520MV-160-BN-TR; ECS-2520MV_4Pin_2.5x2.0mm

Connections:
+5V: C3.1, C20.1, J2.19, J3.19, J4.1 (VBUS), R11.2, U2.1 (VIN), U2.4 (EN2), U2.5 (EN1)
CDONE: D3.2 (A), J1.4, R10.2, U3.7
CRESET: C17.1, J1.3, R6.2, SW1.2, U3.8
FLASH_MISO: J1.6, U1.2, U3.17
FLASH_MOSI: J1.8, U1.5, U3.14
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C17.2, C18.2, C19.2, C20.2, D3.1 (K), D4.1 (K), D5.1 (K), J1.2, J2.1, J2.18, J2.20, J3.1, J3.20, J4.5 (GND), J4.6 (Shield), SW1.1, SW2.1, U1.4, U2.2 (GND), U2.9 (GND), U3.49, X1.2
ICE_BTN: C19.1, J2.15, R12.2, SW2.2, U3.38
ICE_CLK: U3.20, X1.3
ICE_CSN: J1.5, R1.2, U1.1, U3.16
ICE_LED: J3.2, R13.1, U3.11
ICE_SCK: J1.7, R5.2, U1.6, U3.15
IOB_0A: J3.11, U3.46
IOB_2A: J3.10, U3.47
IOB_3B: J3.13, U3.44
IOB_4A: J3.9, U3.48
IOB_5B: J3.12, U3.45
IOB_6A: J3.8, U3.2
IOB_8A: J3.6, U3.4
IOB_9B: J3.7, U3.3
IOB_13B: J3.5, U3.6
IOB_16A: J3.4, U3.9
IOB_18A: J3.3, U3.10
IOB_22A: J2.2, U3.12
IOB_23B: J2.6, U3.21
IOB_24A: J2.3, U3.13
IOB_29B: J2.5, U3.19
IOB_31B: J2.4, U3.18
IOT_36B: J2.8, U3.25
IOT_37A: J2.7, U3.23
IOT_38B: J2.10, U3.27
IOT_39A: J2.9, U3.26
IOT_41A: J2.11, U3.28
IOT_42B: J2.12, U3.31
IOT_43A: J2.13, U3.32
IOT_45A: J2.14, U3.37
IOT_49A: J3.14, U3.43
IOT_51A: J3.15, U3.42
unnamed: D1.1 (K), U3.24
unnamed: D2.2 (BK), R9.2
unnamed: D2.3 (GK), R8.2
unnamed: D2.4 (RK), R7.1
unnamed: D4.2 (A), R11.1
unnamed: D5.2 (A), R13.2
unnamed: J4.2 (D-), R15.1
unnamed: J4.3 (D+), R3.1, R14.1
unnamed: R2.2, U1.3
unnamed: R4.2, U1.7
RGB_B: J3.18, R9.1, U3.39
RGB_G: J3.17, R8.1, U3.40
RGB_R: J3.16, R7.2, U3.41
USB_N: R15.2, U3.34
USB_P: R14.2, U3.35
USB_PU: R3.2, U3.36
VCC_CORE: C1.1, C2.1, C4.1, C8.1, J2.16, U2.7 (VOUT2), U3.5, U3.29, U3.30

Notes on the sheet:
Programming
Power

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
Board: 4 copper layers, 17.8 x 50.8 mm, 46 parts (23 on the bottom side), 55 nets.

File board/doc/ice40-dip40_bom_A.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet
1,,Device_C,C2 C4 C10 C11 C12 C13 C15 C17 C18 C19,100n,C_0603,10,~
2,,Device_C,C20,10u,C_0603,1,~
3,,Device_C,C1 C9,1u,C_0603,2,~
4,,Device_C,C3 C7 C8,2.2u,C_0603,3,~
5,,esynr3z_DiodeRectifier_CDBU0520,D1,CDBU0520,SOD-523F,1,lib_fp://www.comchiptech.com/cms/UserFiles/CDBU0520-RevA728099.pdf
6,,esynr3z_LED_CLMVC-FKC-CGJJM569aBB7a343,D2,CLMVC-FKC-CGJJM569aBB7a343,LED_Cree-PLCC4_2x2mm_CW,1,~
7,,Device_LED_ALT,D3,LED_GREEN,LED_0603,1,~
8,,Device_LED_ALT,D5,LED_ORANGE,LED_0603,1,~
9,,Device_LED_ALT,D4,LED_RED,LED_0603,1,~
10,,Connector_Generic_Conn_01x20,J2 J3,Conn_01x20,PinHeader_1x20_P2.54mm_Vertical,2,~
11,,Connector_Generic_Conn_02x04_Odd_Even,J1,Conn_02x04_Odd_Even,PinHeader_2x04_P2.54mm_Vertical,1,~
12,,Connector_USB_B_Micro,J4,USB_B_Micro,USB_Micro-B_Wurth_629105136821,1,~
13,,Device_R,R3,1.5k,R_0603,1,~
14,,Device_R,R1 R2 R4 R5 R6 R12,10k,R_0603,6,~
15,,Device_R,R10 R13,1k,R_0603,2,~
16,,Device_R,R11,2.2k,R_0603,1,~
17,,Device_R,R8 R9,22,R_0603,2,~
18,,Device_R,R14 R15,68,R_0603,2,~
19,,Device_R,R7,82,R_0603,1,~
20,,Switch_SW_Push,SW1 SW2,SW_Push,PTS830,2,
21,,esynr3z_MemoryFlash_W25Q80DVSNIG,U1,W25Q80DVSNIG,SOIC-8_3.9x4.9mm_P1.27mm,1,https://www.adestotech.com/wp-content/uploads/DS-AT25SF081_045.pdf
22,,esynr3z_FPGA_ICE40UP5K-SG48I,U3,ICE5LP4K-SG48,QFN-48-1EP_7x7mm_P0.5mm_EP5x5mm_ThermalVias,1,
23,,esynr3z_RegulatorLinear_MIC5355-S4YMME,U2,MIC5355-S4YMME,MSOP-8-1EP_3x3mm_P0.65mm_EP2.54x2.8mm_ThermalVias,1,lib_fp://ww1.microchip.com/downloads/en/DeviceDoc/mic5355_6.pdf
24,,esynr3z_Oscillator_ECS-2520MV-XXX,X1,ECS-2520MV-120-BN-TR,ECS-2520MV_4Pin_2.5x2.0mm,1,lib_fp://www.ecsxtal.com/store/pdf/ECS-2520MV.pdf

## Commit log

2018-07-10 Init repo
2018-07-13 Project name change
2018-07-13 Place all components on schematic
2018-07-13 Try to place biggest footprint on board
2018-07-14 Add RGB LED and assign some FPGA IO to pin headers
2018-07-15 Add oscillator
2018-07-15 Add USB connector
2018-07-16 Add footprints to some symbols and trace pin headers and buttons
2018-07-17 Update footprints
2018-07-18 Place and trace all main components
2018-07-19 Place some caps
2018-07-23 Beautify schematic and place all components on PCB
2018-07-23 Fix some DRC errors on PCB
2018-07-23 Add 2 inner layers and route power
2018-07-23 Increase power tracks width
2018-07-24 Beautify Silk and Fab layers
2018-07-25 Add logo and final Silk edits
2018-07-26 Some minor pcb fixes
2018-07-26 Make footprints local
2018-08-04 Fix 3d model paths in project footprints
2018-08-04 Update to kicad 6.0.0-rc1
2018-08-04 Archive project 3d models
2018-08-04 Make symbols project local
2018-08-04 Remove sym lib cache from repo
2018-08-05 Add docs and readme
2018-08-05 Fix typo in readme
2018-09-21 Add gitignore
2018-09-21 Replace 1Mb flash with 8Mb one
2018-09-21 Update docs
2018-09-23 Trace USB data lines into fpga
2018-09-25 Update docs and generator info
2018-09-25 Update doc
2018-09-30 Add info about other fpga supported
2018-09-30 Project rename
2018-09-30 Add schematic image to readme
2018-09-30 Upgrade repo structure
2019-03-04 Update fpga, flash and oscillator
2019-03-04 Add mouser no and update all docs
